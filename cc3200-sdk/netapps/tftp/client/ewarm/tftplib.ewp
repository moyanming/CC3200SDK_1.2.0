# IAR project tftplib.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; NOTERM; SL_PLATFORM_MULTI_THREADED
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: ../; ../../../../driverlib; ../../../../inc; ../../../../oslib; ../../../../simplelink/; ../../../../simplelink/include; ../../../../simplelink/source; ../../../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: tftplib.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: tftp.c tftp6.c
