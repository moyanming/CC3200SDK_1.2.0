# IAR project webserver.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; NOTERM; SL_PLATFORM_MULTI_THREADED
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: ../; ../../../../driverlib; ../../../../inc; ../../../../oslib; ../../../../simplelink/; ../../../../simplelink/include; ../../../../simplelink/source; ../../../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: webserver.out
  group (top)
    ../: base64.c HttpAuth.c HttpCore.c HttpDebug.c HttpDynamic.c HttpSocket.c HttpStatic.c HttpString.c sha1.c strlib.c WebSockHandler.c
