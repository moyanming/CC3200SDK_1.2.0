# IAR project webclient.ewp, settings and files
configuration HTTPClientMinLib (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; __SL__; HTTPCli_LIBTYPE_MIN
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: ../; ../../../../driverlib; ../../../../inc; ../../../../oslib; ../../../../simplelink/; ../../../../simplelink/include; ../../../../simplelink/source; ../../../../simplelink_extlib/provisioninglib; ../../..
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: webclient.out
configuration HTTPClientFullLib (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; SL_PLATFORM_MULTI_THREADED; __SL__; __OSI__
  group (top)
    ../: httpcli.c httpcli.h httpstr.c lookup.c ssock.c urlfile.c
