# IAR project libxmpp.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; NOTERM
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: ; ../; ../../../common/; ../../../../simplelink/; ../../../../simplelink/source; ../../../../simplelink/include; ../../../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: libxmpp.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCIncludePath2: ; ../; ../../../../simplelink/; ../../../../simplelink/source; ../../../../simplelink/include; ../../../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 3
  group (top)
    ../: base64.c xmpp.c
