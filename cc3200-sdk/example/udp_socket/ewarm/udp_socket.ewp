# IAR project udp_socket.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USER_INPUT_ENABLE
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include; ../../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: udp_socket.bin
  ILINK.IlinkOutputFile: udp_socket.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../simplelink/ewarm/NON_OS/Exe/simplelink.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c pinmux.c
    ../../common/: network_common.c startup_ewarm.c uart_if.c udma_if.c
