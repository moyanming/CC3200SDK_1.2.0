# IAR project tftp_client.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; SL_PLATFORM_MULTI_THREADED; USE_FREERTOS
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../simplelink/; ../../../oslib/; ../../../simplelink/source; ../../../simplelink/include; ../../../netapps/tftp/client; ../../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: tftp_client.bin
  ILINK.IlinkOutputFile: tftp_client.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../simplelink/ewarm/OS/Exe/simplelink.a; ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../oslib/ewarm/free_rtos/Exe/free_rtos.a; ../../../netapps/tftp/client/ewarm/Release/Exe/tftplib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c pinmux.c
    ../../common/: network_common.c network_if.c startup_ewarm.c uart_if.c udma_if.c
