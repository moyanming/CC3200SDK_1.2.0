# IAR project idle_profile_nonos.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include; ../../../middleware\framework/pm/; ../../../middleware/soc/; ../../../; ../../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: idle_profile_nonos.bin
  ILINK.IlinkOutputFile: idle_profile_nonos.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../middleware\ewarm/Release/Exe/middleware.a; ../../../simplelink/ewarm/NON_OS_PM/Exe/simplelink.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: lp3p0_board.c lp3p0_plat_ops.c main.c pinmux.c
    ../../common/: network_common.c startup_ewarm.c uart_if.c udma_if.c utils_if.c
