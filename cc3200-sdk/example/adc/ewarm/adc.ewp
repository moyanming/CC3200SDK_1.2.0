# IAR project adc.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: ewarm
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: ; ../; ../../../; ../../../driverlib/; ../../common/; ../../../inc/
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: adc.bin
  ILINK.IlinkOutputFile: adc.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../driverlib/ewarm/Release/Exe/driverlib.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: adc_userinput.c main.c pinmux.c
    ../../common/: startup_ewarm.c uart_if.c
