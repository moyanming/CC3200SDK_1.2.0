# IAR project http_client_demo.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; __SL__
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include; ../../../netapps; ../../../netapps/json/; ../../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: http_client_demo.bin
  ILINK.IlinkOutputFile: http_client_demo.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../simplelink/ewarm/NON_OS/Exe/simplelink.a; ../../../netapps/http/client/ewarm/HTTPClientMinLib/Exe/webclient.a; ../../../netapps/json/ewarm/Release/Exe/json.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c pinmux.c
    ../../common/: network_common.c startup_ewarm.c uart_if.c
