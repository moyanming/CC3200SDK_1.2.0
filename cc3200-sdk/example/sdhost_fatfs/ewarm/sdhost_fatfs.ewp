# IAR project sdhost_fatfs.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\inc/c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../third_party\fatfs\src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sdhost_fatfs.bin
  ILINK.IlinkOutputFile: sdhost_fatfs.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../third_party\fatfs\ewarm\exe\fatfs.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: diskio.c main.c pinmux.c
    ../../common/: startup_ewarm.c uart_if.c
