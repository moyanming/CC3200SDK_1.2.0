# IAR project mqtt_client.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\; ..\sl_mqtt\; ..\sl_mqtt\mqtt_lib\; ..\sl_mqtt\mqtt_lib\client\; ..\sl_mqtt\mqtt_lib\common\; ..\..\common\; ..\..\..\driverlib\; ..\..\..\inc\; ..\..\..\simplelink\; ..\..\..\simplelink\source; ..\..\..\simplelink\include; ..\..\..\oslib\; ..\..\..\third_party\FreeRTOS\source\include\; ..\..\..\third_party\FreeRTOS\source\; ..\..\..\third_party\FreeRTOS\source\portable\IAR\ARM_CM4; ..\..\..\netapps\mqtt\common\; ..\..\..\netapps\mqtt\include\; ..\..\..\netapps\mqtt\client\; ..\..\..\simplelink_extlib\provisioninglib\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: mqtt_client.bin
  ILINK.IlinkOutputFile: mqtt_client.out
  ILINK.IlinkAdditionalLibs: ..\..\..\driverlib\ewarm\Release\Exe\driverlib.a; ..\..\..\simplelink\ewarm\OS\Exe\simplelink.a; ..\..\..\oslib\ewarm\free_rtos\Exe\free_rtos.a; ..\..\..\netapps\mqtt\ewarm\client\Exe\mqtt.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../common/: button_if.c gpio_if.c network_common.c network_if.c startup_ewarm.c timer_if.c uart_if.c utils_if.c
    ../: main.c pinmux.c
