# IAR project get_time.ewp, settings and files
configuration ti_rtos (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; SL_PLATFORM_MULTI_THREADED; USE_TIRTOS
  ICCARM.IExtraOptions: -f; ../../../ti_rtos/ti_rtos_config/ewarm/iar/tirtos/compiler.opt.defs; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../oslib/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include; ../../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: get_time.bin
  ILINK.IlinkOutputFile: get_time.out
  ILINK.IlinkConfigDefines: Flash=0; CC3200_ES_1_2_1=0
  ILINK.IlinkExtraOptions: --search; ../../../ti_rtos/ti_rtos_config/ewarm/iar/tirtos; -f; ../../../ti_rtos/ti_rtos_config/ewarm/iar/tirtos/linker.cmd
  ILINK.IlinkAdditionalLibs: ../../../simplelink/ewarm/OS/Exe/simplelink.a; ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../oslib\ewarm\ti_rtos\Exe\ti_rtos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration free_rtos (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../oslib/; ../../../third_party/FreeRTOS/source/; ../../../third_party/FreeRTOS/source/include/; ../../../third_party/FreeRTOS/source/portable/IAR/ARM_CM4/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include; ../../../simplelink_extlib/provisioninglib
  ILINK.IlinkAdditionalLibs: ../../../simplelink/ewarm/OS/Exe/simplelink.a; ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../oslib/ewarm/free_rtos/Exe/free_rtos.a
  group (top)
    ../../common/: gpio_if.c network_common.c network_if.c startup_ewarm.c timer_if.c uart_if.c udma_if.c
    ../: main.c pinmux.c
