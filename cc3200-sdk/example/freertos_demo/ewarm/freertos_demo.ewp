# IAR project freertos_demo.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\inc/c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USE_FREERTOS
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../oslib/; ../../../third_party/FreeRTOS/source/; ../../../third_party/FreeRTOS/source/include/; ../../../third_party/FreeRTOS/source/portable/IAR/ARM_CM4/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: freertos_demo.bin
  ILINK.IlinkOutputFile: freertos_demo.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../oslib/ewarm/free_rtos/Exe/free_rtos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: main.c pinmux.c
    ../../common/: startup_ewarm.c uart_if.c
