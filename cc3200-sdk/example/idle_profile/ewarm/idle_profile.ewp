# IAR project idle_profile.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; DEBUG_GPIO; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include; ../../../oslib/; ../../../third_party/FreeRTOS/source/; ../../../third_party/FreeRTOS/source/include/; ../../../third_party/FreeRTOS/source/portable/IAR/ARM_CM4; ../../../middleware\framework\pm/; ../../../middleware\framework\timer/; ../../../middleware\driver/; ../../../middleware\driver\hal/; ../../../middleware\soc/; ../../../; ../../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: idle_profile.bin
  ILINK.IlinkOutputFile: idle_profile.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../middleware\ewarm/Release/Exe/middleware.a; ../../../oslib/ewarm/free_rtos/Exe/free_rtos.a; ../../../simplelink/ewarm\PM_Framework\Exe\simplelink.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: lp3p0_board.c lp3p0_plat_ops.c main.c pinmux.c
    ../../common/: network_common.c startup_ewarm.c utils_if.c wdt_if.c
