# IAR project websock_camera.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED; ENABLE_JPEG; NOTERM
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../simplelink/; ../../../oslib/; ../../../simplelink/source; ../../../simplelink/include; ../../../netapps/http/server; ../../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: websock_camera.bin
  ILINK.IlinkOutputFile: websock_camera.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ../../../simplelink/ewarm/OS/Exe/simplelink.a; ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../oslib/ewarm/free_rtos/Exe/free_rtos.a; ../../../netapps\http\server\ewarm/Release/Exe/webserver.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    ../: camera_app.c httpserverapp.c i2cconfig.c main.c mt9d111.c pinmux.c
    ../../common/: network_common.c network_if.c startup_ewarm.c udma_if.c
