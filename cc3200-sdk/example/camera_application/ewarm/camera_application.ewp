# IAR project camera_application.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: SL_PLATFORM_MULTI_THREADED; PLATFORM_LP; ewarm; USE_FREERTOS; NOTERM; QVGA_FRAME; ENABLE_JPEG
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include; ../../../oslib/; ../../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: camera_application.bin
  ILINK.IlinkOutputFile: camera_application.out
  ILINK.IlinkIcfFile: camera_application.icf
  ILINK.IlinkAdditionalLibs: ../../../simplelink/ewarm/OS/Exe/simplelink.a; ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../oslib/ewarm/free_rtos/Exe/free_rtos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../: camera_app.c i2cconfig.c main.c mt9d111.c pinmux.c startup_ewarm.c
    ../../common/: gpio_if.c network_common.c uart_if.c udma_if.c
