# IAR project ota_update_nonos.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ..\..\; ..\..\..\common\; ..\..\..\..\driverlib\; ..\..\..\..\inc\; ..\..\..\..\oslib\; ..\..\..\..\third_party\FreeRTOS\source\; ..\..\..\..\third_party\FreeRTOS\source\include\; ..\..\..\..\third_party\FreeRTOS\source\portable\IAR\ARM_CM4\; ..\..\..\..\simplelink\; ..\..\..\..\simplelink_extlib\flc; ..\..\..\..\simplelink_extlib\include\; ..\..\..\..\simplelink\source; ..\..\..\..\simplelink\include; ..\..\..\..\simplelink_extlib\provisioninglib\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: ota_update_nonos.bin
  ILINK.IlinkOutputFile: ota_update_nonos.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkAdditionalLibs: ..\..\..\..\simplelink\ewarm\NON_OS\Exe\simplelink.a; ..\..\..\..\driverlib\ewarm\Release\Exe\driverlib.a; ..\..\..\..\simplelink_extlib\ota\ewarm\Release\Exe\ota.a; ..\..\..\..\simplelink_extlib\flc\ewarm\Release\Exe\flc.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../../common/: button_if.c network_common.c startup_ewarm.c uart_if.c udma_if.c
    ../: main.c net.c pinmux.c task.c
