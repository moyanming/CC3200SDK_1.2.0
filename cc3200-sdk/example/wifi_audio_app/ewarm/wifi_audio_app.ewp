# IAR project wifi_audio_app.ewp, settings and files
configuration UniCast (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm; USE_FREERTOS; SL_PLATFORM_MULTI_THREADED; NOTERM
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: $PROJ_DIR$; ../; ../../common/; ../../../driverlib/; ../../../inc/; ../../../oslib/; ../../../simplelink/; ../../../simplelink/source; ../../../simplelink/include; ../../../simplelink_extlib/provisioninglib
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: wifi_audio_app.bin
  ILINK.IlinkOutputFile: wifi_audio_app.out
  ILINK.IlinkConfigDefines: CC3200_ES_1_2_1=0
  ILINK.IlinkIcfFile: wifi_audio_app.icf
  ILINK.IlinkAdditionalLibs: ../../../simplelink/ewarm/OS/Exe/simplelink.a; ../../../driverlib/ewarm/Release/Exe/driverlib.a; ../../../oslib/ewarm/free_rtos/Exe/free_rtos.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration MultiCast (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; USE_FREERTOS; TI_CODEC; PLAY_BACK; SL_PLATFORM_MULTI_THREADED; MULTICAST; NOTERM
  ILINK.IlinkOutputFile: wifi_audio_app_multicast.out
  group (top)
    ../: audiocodec.c circ_buff.c control.c main.c microphone.c network.c pcm_handler.c pinmux.c smartconfig.c speaker.c
    ../../common/: gpio_if.c i2c_if.c i2s_if.c network_common.c startup_ewarm.c uart_if.c udma_if.c
