# IAR project middleware.ewp, settings and files
configuration Release (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: ../driver/hal/; ../framework/pm/; ../framework/timer/; ../soc; ../../driverlib/; ../../inc/; ../../oslib/
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: middleware.out
  group driver
    ../driver/: spi_drv.c uart_drv.c
  group driver/hal
    ../driver/hal/: dma_hal.c gpio_hal.c hw_timer32.c interrupt_hal.c rtc_hal.c spi_hal.c uart_hal.c util64.c
  group pm_fmwk
    ../framework/pm/: cc_pm.c
  group soc_services
    ../soc/: cc_io_park.c cc_pm_ops.c
  group timer_fmwk
    ../framework/timer/: cc_timer.c
