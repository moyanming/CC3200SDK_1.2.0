# IAR project flc.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.CCDiagSuppress: Pa050
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: ..\..\include\; ..\..\..\driverlib\; ..\..\..\inc\; ..\..\..\simplelink\; ..\..\..\simplelink\Include\; ..\..\..\simplelink\Source\; ..\..\..\simplelink_extlib\provisioninglib\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: ewarm
  OBJCOPY.OOCOutputFile: extlib_file_commit-cm3.srec
  ILINK.IlinkOutputFile: extlib_file_commit-cm3.out
configuration Release_Fastboot (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: ewarm; FAST_BOOT
  group (top)
    ../: flc.c
    ../../include/: flc_api.h
