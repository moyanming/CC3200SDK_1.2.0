# IAR project oslib.ewp, settings and files
configuration free_rtos (ARM, debug)
  General.OGChipSelectEditMenu: CC3200 TexasInstruments CC3200
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: ewarm
  ICCARM.IExtraOptions: --diag_suppress Pa050
  ICCARM.CCIncludePath2: ..; ../../driverlib; ../../inc; ../../third_party/FreeRTOS/source/; ../../third_party/FreeRTOS/source/include; ../../third_party/FreeRTOS/source/portable/IAR/ARM_CM4
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..; ../../third_party\FreeRTOS\source/; ../../third_party\FreeRTOS\source\include; ../../third_party\FreeRTOS\source\portable\IAR\ARM_CM4
  ILINK.IlinkOutputFile: oslib.out
configuration ti_rtos (ARM)
  as the first configuration, except:
  ICCARM.IExtraOptions: -f; ../../ti_rtos/ti_rtos_config/ewarm/iar/tirtos/compiler.opt.defs; --diag_suppress=Pa050
  ICCARM.CCIncludePath2: ..; ../../ti_rtos/ti_rtos_config/ewarm/iar/tirtos
  group (top)
    ../../third_party/FreeRTOS/source/: croutine.c list.c queue.c tasks.c timers.c
    ../../third_party/FreeRTOS/source/portable/MemMang/: heap_3.c
    ../: osi_freertos.c osi_tirtos.c
    ../../third_party/FreeRTOS/source/portable/IAR/ARM_CM4/: port.c portasm.s
